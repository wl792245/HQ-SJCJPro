# Keil uVision project HXJZQPro.uvprojx, settings and files
target 恒信集中器 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HXJZQPro
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CORE\inc;..\FWlib\inc;..\MCU_FUN\inc;..\DRIVER\inc;..\HARDWARE\inc;..\TLSF\inc;..\NET\device\inc;..\FRAMEWORK\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ../CORE/src/: core_cm3.c stm32f10x_it.c sys.c system_stm32f10x.c
  group fwlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_bkp.c
  group startup
    ../STARTUP/: startup_stm32f10x_hd.s
  group mcu_fun
    ../MCU_FUN/src/: mcu_dma.c mcu_gpio.c mcu_rcc.c mcu_usart.c mcu_nvic.c mcu_timer.c
  group driver
    ../DRIVER/src/: delay.c usart.c hwtimer.c rtc.c
  group hardware
    ../HARDWARE/src/: led.c dht11.c
  group user
    ./: main.c
  group net_device
    ../NET/device/src/: net_device.c net_io.c
  group framework
    ../FRAMEWORK/src/: framework.c
  group tlsf
    ../TLSF/src/: tlsf.c
  group readme
    ../README/: readme.txt
